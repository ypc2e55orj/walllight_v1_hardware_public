# Repository ypc2e55orj/walllight_v1_hardware_public

## KiCad design walllight_v1_main.kicad_pcb

Parts:
C1: 47u 25V; C_1206_3216Metric
C2, C3, C4, C13: 10u 25V; C_0603_1608Metric
C5, C6, C7, C8, C10, C16, C19, C20, C21, C22, C24, C26, C27: 0.1u 50V; C_0402_1005Metric
C9, C18: 4.7u 6.3V; C_0402_1005Metric
C11, C14: 2.2u 6.3V; C_0402_1005Metric
C12: 3.3n 50V; C_0402_1005Metric
C15: 22u 10V; C_0603_1608Metric
C17: 4.7u 10V; C_0402_1005Metric
C23: 1u 50V; C_0402_1005Metric
C25: 10u 6.3V; C_0402_1005Metric
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_0402_1005Metric
J1: SFM210-LPSE-D03-ST-BK; PinHeader_2x03_P1.00mm_Vertical
J2: B2B-ZR; JST_ZH_B2B-ZR_1x2_P1.50mm_Vertical
J3, J4, J5, J6, J7, J8: Conn_01x01_Socket; PinHeader_1x01_P1.00mm_Vertical
J9: Conn_01x04_Pin; WallLight_Encoder_Main-4_Ch2
J10: Conn_01x04_Pin; WallLight_Encoder_Main-4_Ch1
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1, R2, R3, R4, R5, R6, R12, R13: TBD; R_0402_1005Metric
R7: 30k 1%; R_0402_1005Metric
R8, R9: 10k 1%; R_0402_1005Metric
R10: 100k 1%; R_0402_1005Metric
R11: 536k 1%; R_0402_1005Metric
R14, R15, R20, R21: 1.2k 0.5%; R_0402_1005Metric
R16, R17, R18, R19: 10 1% 1/10W; R_0402_1005Metric
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK
SW2: SPDT_PCM12; SW_SPDT_PCM12
U1, U2, U3: MP6551GQB; MPS_QFN-14_2.5x3mm_P0.5mm
U4: TPS82140; Texas_SIL0008D_MicroSiP-8-1EP_2.8x3mm_P0.65mm_EP1.1x1.9mm_T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
U5: STM32H573RIVx; QFN-68-1EP_8x8mm_P0.4mm_EP6.4x6.4mm
U6: ST1L05C; DFN-6-1EP_3x3mm_P0.95mm_EP1.7x2.6mm
U7: CY15B108QN-40LPXI; Infineon_GQFN-8_3.23x3.28mm_P0.65mm
U8, U15: WallSensor_FrontRight_Left; WallLight_WallSensor-4_D3.0mm_FrontRight_Left
U9, U14: WallSensor_FrontLeft_Right; WallLight_WallSensor-4_D3.0mm_FrontLeft_Right
U10, U11, U12, U13: BCR421UW6; SOT-23-6
U16: LSM6DSRV; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y

Connections:
+3V3: C8.1, C9.1, C10.1, C16.1, C18.1, C19.1, C20.1, C22.1, C23.1, C25.1, C26.1, C27.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), J1.1, J9.1, J10.1, U5.1 (VBAT), U5.13 (VDDA), U5.19 (VDD), U5.33 (VDD), U5.51 (VDD), U5.68 (VDD), U6.4 (V_{O}), U6.5 (V_{O_SENSE}), U7.8 (VDD), U8.4, U9.2, U14.2, U15.4, U16.5 (Vdd_IO), U16.8 (Vdd)
+5V: C15.1, C17.1, R11.1, U4.4 (VOUT), U4.5 (VOUT), U6.6 (V_{I}), U8.1, U9.3, U14.3, U15.1
+BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C13.1, J2.1, R7.1, SW2.2 (B), U1.2 (VIN), U2.2 (VIN), U3.2 (VIN), U4.2 (VIN)
-BATT: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J2.2, NT1.1, U1.6 (SR), U1.9 (GND), U2.6 (SR), U2.9 (GND), U3.6 (SR), U3.9 (GND)
/BATT_SENS: R7.2, R8.1, U5.24 (PC4)
/BUTTON1: SW1.2, U5.48 (PA12)
/DCDC_EN: SW2.1 (A), U4.1 (EN)
/DRIVE1_IN1: U1.13 (IN1), U5.47 (PA11)
/DRIVE1_IN2: U1.5 (IN2), U5.46 (PA10)
/DRIVE2_IN1: U2.13 (IN1), U5.45 (PA9)
/DRIVE2_IN2: U2.5 (IN2), U5.44 (PA8)
/DRIVE_EN: U1.4 (EN2), U1.14 (EN1), U2.4 (EN2), U2.14 (EN1), U5.43 (PC9)
/DRIVE_NFAULT: U1.12 (nFAULT), U2.12 (nFAULT), U5.41 (PC7)
/ENCODER1_VOUT1: J10.2, U5.61 (PB7)
/ENCODER1_VOUT2: J10.3, U5.60 (PB6)
/ENCODER2_VOUT1: J9.2, U5.58 (PB4(NJTRST))
/ENCODER2_VOUT2: J9.3, U5.59 (PB5)
/FRAM_SCK: U5.21 (PA5), U7.6 (SCK)
/FRAM_SI: U5.23 (PA7), U7.5 (SI)
/FRAM_SO: U5.22 (PA6), U7.2 (SO)
/IMU_CS: U5.53 (PA15(JTDI)), U16.12 (CS)
/IMU_SCL: U5.54 (PC10), U16.13 (SCL)
/IMU_SDA: U5.56 (PC12), U16.14 (SDA)
/IMU_SDO: U5.55 (PC11), U16.1 (SDO/SA0)
/IR_EN1: U5.17 (PA3), U10.1 (EN)
/IR_EN2: U5.16 (PA2), U13.1 (EN)
/IR_EN3: U5.15 (PA1), U12.1 (EN)
/IR_EN4: U5.14 (PA0), U11.1 (EN)
/LED1: R1.2, U5.30 (PB11)
/LED2: R2.2, U5.29 (PB10)
/LED3: R3.2, U5.28 (PB2)
/LED4: R4.2, U5.27 (PB1)
/LED5: R5.2, U5.26 (PB0)
/LED6: R6.2, U5.25 (PC5)
/LED7: R12.2, U5.2 (PC13)
/LED8: R13.2, U5.3 (PC14)
/NRST: C21.1, J1.3, U5.7 (NRST)
/PA13: J1.2, U5.49 (PA13(JTMS)
/PA14: J1.4, U5.52 (PA14(JTCK)
/PB3: J1.6, U5.57 (PB3(JTDO)
/PHTR_SENS1: R14.1, U5.11 (PC3), U9.1
/PHTR_SENS2: R20.1, U5.10 (PC2), U15.3
/PHTR_SENS3: R21.1, U5.9 (PC1), U14.1
/PHTR_SENS4: R15.1, U5.8 (PC0), U8.3
/SUCTION_EN: U3.4 (EN2), U3.14 (EN1), U5.40 (PC6)
/SUCTION_IN1: U3.13 (IN1), U5.37 (PB15)
/SUCTION_IN2: U3.5 (IN2), U5.36 (PB14)
/SUCTION_NFAULT: U3.12 (nFAULT), U5.38 (PD11)
/~FRAM_CS: U5.20 (PA4), U7.1 (~CS)
GND: C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, J1.5, J9.4, J10.4, NT1.2, R8.2, R9.2, R10.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, SW1.1, U4.3 (GND), U4.9 (GND), U5.12 (VSSA), U5.18 (VSS), U5.32 (VSS), U5.50 (VSS), U5.67 (VSS), U5.69 (VSS), U6.2 (GND), U6.7 (GND), U7.4 (GND), U10.4 (GND), U11.4 (GND), U12.4 (GND), U13.4 (GND), U16.2 (SDx), U16.3 (SCx), U16.6 (GND), U16.7 (GND)
unnamed: C11.1, U5.31 (VCAP)
unnamed: C14.1, U5.66 (VCAP)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: D6.1 (K), R6.1
unnamed: D7.1 (K), R12.1
unnamed: D8.1 (K), R13.1
unnamed: J3.1 (Pin_1_1), U1.3 (OUT2), U1.8 (OUT2)
unnamed: J4.1 (Pin_1_1), U2.3 (OUT2), U2.8 (OUT2)
unnamed: J5.1 (Pin_1_1), U3.3 (OUT2), U3.8 (OUT2)
unnamed: J6.1 (Pin_1_1), U1.1 (OUT1), U1.10 (OUT1)
unnamed: J7.1 (Pin_1_1), U2.1 (OUT1), U2.10 (OUT1)
unnamed: J8.1 (Pin_1_1), U3.1 (OUT1), U3.10 (OUT1)
unnamed: R10.1, R11.2, U4.6 (FB)
unnamed: C12.1, U4.8 (SS/TR)
unnamed: R9.1, U5.62 (BOOT0)
unnamed: C24.1, U6.1 (EN)
unnamed: U9.4, U10.2 (OUT), U10.3 (OUT), U10.5 (OUT)
unnamed: R16.1, U10.6 (R_{EXT})
unnamed: U8.2, U11.2 (OUT), U11.3 (OUT), U11.5 (OUT)
unnamed: R17.1, U11.6 (R_{EXT})
unnamed: U12.2 (OUT), U12.3 (OUT), U12.5 (OUT), U14.4
unnamed: R18.1, U12.6 (R_{EXT})
unnamed: U13.2 (OUT), U13.3 (OUT), U13.5 (OUT), U15.2
unnamed: R19.1, U13.6 (R_{EXT})

Notes on the sheet:
VDD
95 mA
壁センサー回路
VBAT
To NJL5820R Sub Board
VDDA
DEBUG_JTCK-SWCLK
制御回路
LiPo 2cell - 3cell
ERC
駆動回路
DEBUG_JTDO-SWO
DEBUG_JTMS-SWDIO
電源回路
2cell 08.4V -> 6.20V:2.10V 3cell 12.6V -> 9.45V:3.15V
駆動センサー回路
デカップリング

Board: 2 copper layers, 38.9 x 58.2 mm, 87 parts (4 on the bottom side), 78 nets.

Other parts of the board:
_DONT_USE_MODEL_CHECK_CH1: WallLight_Drive_Unit_Ch1
_DONT_USE_MODEL_CHECK_CH2: WallLight_Drive_Unit_Ch2
